# Keil uVision project lab.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtos-elevator
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group header
    ./headers/: CLI.h USART.h MY_STM32_FUNCTIONS.h util.h TIM.h TASKS.h
  group src
    ./src/: main.c CLI.c USART.c MY_STM32_FUNCTIONS.c util.c TIM.c TASKS.c
  group LCD
    ./src/: i2c.c i2c_lcd_driver.c
    ./headers/: i2c.h i2c_lcd_driver.h IOdef.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS:FreeRTOS 10.5.1, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0
